# Keil uVision project PA7parts1&2.uvprojx, settings and files
target PA7part1&2ESP8266 (6220000::V6.22::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PA5
  c flags: Optim=1 OneElfS=1 v6Lang=6 v6LangP=9 wLevel=3
  c define: rvmdk PART_TM4C123GH6PM
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s main.c pll.c UART.c LED.c esp8266.c
software components: CMSIS:CORE 6.1.0
